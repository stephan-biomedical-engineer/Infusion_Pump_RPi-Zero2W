FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://pwm-cdev.cfg"
